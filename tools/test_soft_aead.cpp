// Host-side KAT for SoftAesGcm / SoftChaChaPoly (compile: g++ -I../src -I../src/backends -I../src/crypto test_soft_aead.cpp ../src/backends/SoftAes128.cpp ../src/backends/SoftAesGcm.cpp ../src/backends/SoftChaChaPoly.cpp -o test_soft_aead)

#include <cstdio>
#include <cstring>

#include "backends/SoftAesGcm.h"
#include "backends/SoftChaChaPoly.h"
#include "crypto/CryptoTypes.h"

using namespace ncrypto;

static bool eq(const uint8_t* a, const uint8_t* b, size_t n) {
  return memcmp(a, b, n) == 0;
}

int main() {
  const uint8_t gcmKey[16] = {0xfe, 0xff, 0xe9, 0x92, 0x86, 0x65, 0x73,
                              0x1c, 0x6d, 0x6a, 0x8f, 0x94, 0x67, 0x30,
                              0x83, 0x08};
  const uint8_t gcmIv[12] = {0xca, 0xfe, 0xba, 0xbe, 0xfa, 0xce,
                             0xdb, 0xad, 0xde, 0xca, 0xf8, 0x88};
  const uint8_t gcmPt[64] = {
      0xd9, 0x31, 0x32, 0x25, 0xf8, 0x84, 0x06, 0xe5, 0xa5, 0x59, 0x09, 0xc5,
      0xaf, 0xf5, 0x26, 0x9a, 0x86, 0xa7, 0xa9, 0x53, 0x15, 0x34, 0xf7, 0xda,
      0x2e, 0x4c, 0x30, 0x3d, 0x8a, 0x31, 0x8a, 0x72, 0x1c, 0x3c, 0x0c, 0x95,
      0x95, 0x68, 0x09, 0x53, 0x2f, 0xcf, 0x0e, 0x24, 0x49, 0xa6, 0xb5, 0x25,
      0xb1, 0x6a, 0xed, 0xf5, 0xaa, 0x0d, 0xe6, 0x57, 0xba, 0x63, 0x7b, 0x39,
      0x1a, 0xaf, 0xd2, 0x55};
  const uint8_t gcmCtExp[64] = {
      0x42, 0x83, 0x1e, 0xc2, 0x21, 0x77, 0x74, 0x24, 0x4b, 0x72, 0x21, 0xb7,
      0x84, 0xd0, 0xd4, 0x9c, 0xe3, 0xaa, 0x21, 0x2f, 0x2c, 0x02, 0xa4, 0xe0,
      0x35, 0xc1, 0x7e, 0x23, 0x29, 0xac, 0xa1, 0x2e, 0x21, 0xd5, 0x14, 0xb2,
      0x54, 0x66, 0x93, 0x1c, 0x7d, 0x8f, 0x6a, 0x5a, 0xac, 0x84, 0xaa, 0x05,
      0x1b, 0xa3, 0x0b, 0x39, 0x6a, 0x0a, 0xac, 0x97, 0x3d, 0x58, 0xe0, 0x91,
      0x47, 0x3f, 0x59, 0x85};
  const uint8_t gcmTagExp[16] = {0x4d, 0x5c, 0x2a, 0xf3, 0x27, 0xcd, 0x64,
                                 0xa6, 0x2c, 0xf3, 0x5a, 0xbd, 0x2b, 0xa6,
                                 0xfa, 0xb4};

  uint8_t ct[64], tag[16], pt2[64];
  bool gcmEnc =
      SoftAesGcm::encrypt(gcmKey, gcmIv, nullptr, 0, gcmPt, ct, 64, tag);
  bool gcmCtOk = eq(ct, gcmCtExp, 64);
  bool gcmTagOk = eq(tag, gcmTagExp, 16);
  bool gcmDec = SoftAesGcm::decrypt(gcmKey, gcmIv, nullptr, 0, gcmCtExp, pt2,
                                    64, gcmTagExp);
  bool gcmPtOk = eq(pt2, gcmPt, 64);
  std::printf("GCM enc=%d ct=%d tag=%d dec=%d pt=%d\n", gcmEnc, gcmCtOk,
              gcmTagOk, gcmDec, gcmPtOk);
  if (!gcmCtOk) {
    std::printf("GCM ct got: ");
    for (int i = 0; i < 64; ++i) std::printf("%02x", ct[i]);
    std::printf("\n");
  }
  if (!gcmTagOk) {
    std::printf("GCM tag got: ");
    for (int i = 0; i < 16; ++i) std::printf("%02x", tag[i]);
    std::printf("\n");
  }

  const uint8_t chaKey[32] = {
      0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89, 0x8a, 0x8b,
      0x8c, 0x8d, 0x8e, 0x8f, 0x90, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97,
      0x98, 0x99, 0x9a, 0x9b, 0x9c, 0x9d, 0x9e, 0x9f};
  const uint8_t nonce[12] = {0x07, 0x00, 0x00, 0x00, 0x41, 0xb0,
                             0x51, 0xec, 0x5e, 0x98, 0x56, 0x63};
  const uint8_t aad[8] = {0x50, 0x51, 0x52, 0x53, 0x54, 0x55, 0x56, 0x57};
  const uint8_t chaPt[32] = {
      0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b,
      0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
      0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f};
  const uint8_t chaCtExp[32] = {
      0x10, 0xab, 0x09, 0x03, 0x36, 0x4f, 0x86, 0xd6, 0x9d, 0x82, 0x82, 0xf6,
      0x9d, 0xd2, 0x35, 0xc3, 0xc1, 0xd9, 0xdd, 0xcb, 0x11, 0x0b, 0x4b, 0xa9,
      0xc7, 0xcd, 0x32, 0xe7, 0x1c, 0xe8, 0xa8, 0x93};
  const uint8_t chaTagExp[16] = {0x66, 0x48, 0xaa, 0x82, 0x1b, 0x78, 0x61,
                                 0x95, 0x08, 0x75, 0xf9, 0x5b, 0x2c, 0xe5,
                                 0x6e, 0x5f};

  uint8_t chaCt[32], chaTag[16], chaPt2[32];
  bool chaEnc = SoftChaChaPoly::encrypt(chaKey, nonce, aad, sizeof(aad), chaPt,
                                        chaCt, 32, chaTag);
  bool chaCtOk = eq(chaCt, chaCtExp, 32);
  bool chaTagOk = eq(chaTag, chaTagExp, 16);
  bool chaDec = SoftChaChaPoly::decrypt(chaKey, nonce, aad, sizeof(aad),
                                        chaCtExp, chaPt2, 32, chaTagExp);
  bool chaPtOk = eq(chaPt2, chaPt, 32);
  std::printf("Cha enc=%d ct=%d tag=%d dec=%d pt=%d\n", chaEnc, chaCtOk,
              chaTagOk, chaDec, chaPtOk);
  if (!chaCtOk) {
    std::printf("Cha ct got: ");
    for (int i = 0; i < 32; ++i) std::printf("%02x", chaCt[i]);
    std::printf("\n");
  }
  if (!chaTagOk) {
    std::printf("Cha tag got: ");
    for (int i = 0; i < 16; ++i) std::printf("%02x", chaTag[i]);
    std::printf("\n");
  }

  return (gcmCtOk && gcmTagOk && gcmDec && gcmPtOk && chaCtOk && chaTagOk &&
          chaDec && chaPtOk)
             ? 0
             : 1;
}
